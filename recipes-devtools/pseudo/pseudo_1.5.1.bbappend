FILESEXTRAPATHS_prepend := "${THISDIR}/files"
SRC_URI += " file://0001-fix-static-var-for-gcc-5.patch"
